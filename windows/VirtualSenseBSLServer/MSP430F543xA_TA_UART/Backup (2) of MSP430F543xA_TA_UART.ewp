# IAR project Backup (2) of MSP430F543xA_TA_UART.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5418A MSP430F5418A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ../Command_Interpreter/; ../API/; ../Peripheral_Interfaces/; ../Peripheral_Interfaces/Timer_A_UART/
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430_BSL_AREA_RAM_1C00-5BFF.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../API/: BSL430_API.c
    ../Command_Interpreter/: BSL430_Command_Interpreter.c
    ./: BSL430_Low_Level_Init.s43 BSL_Device_File.h
    ../Peripheral_Interfaces/Timer_A_UART/: BSL430_PI_TA.c
