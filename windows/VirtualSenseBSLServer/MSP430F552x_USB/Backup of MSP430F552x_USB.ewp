# IAR project Backup of MSP430F552x_USB.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5513 MSP430F5513
  General.GStackSize2: 400
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ../Command_Interpreter/; ../API/; ../Peripheral_Interfaces/; ../Peripheral_Interfaces/USB/
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430_BSL_AREA_RAM_2400-33FF.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../API/: BSL430_API.c
    ../Command_Interpreter/: BSL430_Command_Interpreter.c
    ./: BSL430_Low_Level_Init.s43
  group USB_PI
    ../Peripheral_Interfaces/USB/: BSL430_USB_PI.c cstartup.s43 descriptors.c hal_UCS.c usb.c UsbApi.c UsbHidReq.c UsbIsr.c
